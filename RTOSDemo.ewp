# IAR project RTOSDemo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S6965 TexasInstruments LM3S6965
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: IAR_ARMCM3_LM; PACK_STRUCT_END=
  ICCARM.CCDiagSuppress: pe550, pe144, pa039
  ICCARM.CCIncludePath2: ; ..\Common\drivers\LuminaryMicro; ..\common\include; ..\..\source\include; webserver; ..\Common\ethernet\uIP\uip-1.0\uip; C:\StellarisWare\inc; C:\StellarisWare\boards\ek-lm3s8962\drivers; C:\StellarisWare; C:\StellarisWare\boards\ek-lm3s8962; ..\..\..\third_party\lwip-1.3.2\apps; ..\..\..\third_party\lwip-1.3.2\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.2\src\include; ..\..\..\third_party\lwip-1.3.2\src\include\ipv4C:\Users\RJYou\OneDrive\Desktop\FreeRTOSv9.0.0\FreeRTOS\third_party\lwip-1.3.2\src\include\lwip; C:\Users\RJYou\OneDrive\Desktop\FreeRTOSv9.0.0\FreeRTOS\third_party\lwip-1.3.2\apps; C:\Users\RJYou\OneDrive\Desktop\FreeRTOSv9.0.0\FreeRTOS\third_party\lwip-1.3.2\src\include\lwip; C:\StellarisWare\utils; C:\StellarisWare\third_party\lwip-1.3.2\src\include; C:\StellarisWare\third_party\lwip-1.3.2\ports\stellaris\include; C:\StellarisWare\third_party\lwip-1.3.2\src; C:\StellarisWare\third_party\lwip-1.3.2\src\..\..\; C:\StellarisWare\third_party\lwip-1.3.2\src\..\; C:\StellarisWare\third_party\lwip-1.3.2\src\include\ipv4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  ILINK.IlinkOutputFile: RTOSDemo.out
  ILINK.IlinkIcfFile: LM3Sxxxx.icf
  ILINK.IlinkAdditionalLibs: ..\Common\drivers\LuminaryMicro\IAR\driverlib.a; ..\Common\drivers\LuminaryMicro\IAR\grlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Demo files
    ../Common/Minimal/: BlockQ.c blocktim.c death.c EventGroupsDemo.c flash.c GenQTest.c integer.c IntQueue.c PollQ.c QPeek.c QueueSet.c recmutex.c semtest.c
    ./: bool.c bool.h computeTask.c computeTask.h dataPtrs.c dataPtrs.h dataStructs.c displayTask.c displayTask.h Flags.h IntQueueTimer.c keypadTask.c keypadTask.h main.c measureTask.c measureTask.h serialComTask.c serialComTask.h statusTask.c statusTask.h systemTimeBase.c systemTimeBase.h warningAlarm.c warningAlarm.h
    ParTest/: ParTest.c
    ../CORTEX_LM3Sxxxx_IAR_Keil/: timertest.c
  group Ethernet
    ../../../../../Documents/IAR Embedded Workbench/arm/8.20.1/TexasInstruments/Stellaris/boards/ek-lm3s8962/enet_io/: cgifuncs.c io.c
    ../../../../../Documents/IAR Embedded Workbench/arm/8.20.1/TexasInstruments/Stellaris/third_party/lwip-1.3.2/apps/httpserver_raw/: httpd.c
    ./: lmi_fs.c
    ../../../../../Documents/IAR Embedded Workbench/arm/8.20.1/TexasInstruments/Stellaris/utils/: locator.c lwiplib.c
  group Library files
    ../Common/drivers/LuminaryMicro/IAR/: driverlib.a grlib.a
    ./: formike128x128x16.c osram128x64x4.c rit128x96x4.c
    ../../../../../../../../StellarisWare/inc/: hw_types.h
  group Scheduler files
    ../../Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../Source/portable/MemMang/: heap_4.c
    ../../Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group System files
    ./: startup_ewarm.c
